# Keil uVision project STM32L433.uvprojx, settings and files
target STM32L433 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L433_OUT +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx
  c misc: --no_conditionalize
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../App/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\zqjqr\CONFIG;..\zqjqr\GUI_APP;..\zqjqr\TASK;..\zqjqr\SYSTEM\sys;..\zqjqr\HARDWARE\interface;..\zqjqr\SENSORS\interface;..\zqjqr\COMMON\interface;..\zqjqr\COMMUNICATE\interface;..\zqjqr\MALLOC;..\zqjqr\GLOBAL
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xff80
  memory RVCT10: RAM 0x2000ff80 size 0x80
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group ARM-MDK
    ./: startup_stm32l433xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Hard_ware
    ../zqjqr/HARDWARE/src/: lcd.c text.c zqjqr_log.c font.c rtc.c key.c w25qxx.c mpu9250.c MS5837.c uart_link.c print.c uart_si446.c bat_adc.c gpio_control.c
  group Gui_app
    ../zqjqr/GUI_APP/: depth_ui.c language_ui.c logger_display.c main_ui.c match_ui.c menu_display.c mode_display.c reset_ui.c set_display.c time_ui.c endDive_ui.c update_ui.c gps_ui.c
  group Task
    ../zqjqr/TASK/: displayTask.c keyTask.c storageTask.c rtcTask.c sensorsTask.c
    ../zqjqr/COMMUNICATE/src/: atkp.c radiolink.c
  group Sensor
    ../zqjqr/SENSORS/src/: imu.c barometer.c
  group Common
    ../zqjqr/COMMON/src/: maths.c filter.c
  group Malloc
    ../zqjqr/MALLOC/: malloc.c
  group Group
    ../zqjqr/GLOBAL/: global.c
software components: CMSIS:CORE 4.3.0
